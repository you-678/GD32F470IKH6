# Keil uVision project F470IKH6_demo.uvprojx, settings and files
target GD32F470IKH6_demo (6190000::V6.19::ARMCLANG)
  device: GD32F470IK GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0300000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F470IKH6_demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\Firmware\GD32F4xx_standard_peripheral\Include;..\Firmware\CMSIS;..\Firmware\CMSIS\GD\GD32F4xx\Include;..\User;..\BSP;..\Components\drivers;..\Components\images;..\Components\drivers\OV2640;..\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c gd32f4xx_libopt.h bsp_pin_def.h
  group CMSIS
    ../Firmware/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
    ../Firmware/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
  group Firmware
    ../Firmware/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group BSP
    ../BSP/: bsp_led.c bsp_key.c bsp_usart.c bsp_adc.c bsp_dac.c bsp_i2c.c bsp_spi.c bsp_i2s.c bsp_exmc.c bsp_sdio.c bsp_can.c bsp_clockout.c bsp_ctc.c bsp_pmu.c bsp_rtc.c bsp_timer.c bsp_tli.c bsp_ipa.c bsp_sccb.c bsp_dci.c bsp_trng.c
  group Components
    ../Components/drivers/: drv_at24c02.c drv_gd25qxx.c drv_i2s_player.c drv_wav.c wave_data.c drv_storage.c drv_sdcard.c
    ../Components/drivers/OV2640/: dci_ov2640.c
  group App
    ../App/: app_led.c app_key.c app_usart.c app_adc.c app_dac.c app_i2c_eeprom.c app_sdcard.c app_can.c app_clockout.c app_ctc.c app_sleep.c app_rtc.c app_breath.c app_lcd.c app_camera.c app_scheduler.c app_nb_led.c app_nb_key.c
  group images
    ../Components/images/: image1.h image2.h image3.h image4.h image5.h image6.h image7.h image8.h image9.h image10.h image11.h image12.h logo.h picture.c
  group Doc
    ../Doc/: readme.txt
